Commit message: add random robot & success on dynamics function

File: stl/tecobot_test.urdf (robot description, URDF)
Before this commit: robot tecobot, 8 links, 7 joints
Joints:
- joint j2: origin xyz=0 0.11115 -6.411407844118837e-06 rpy=-1.5708 0 3.1416 -> xyz=0 0.11115 0 rpy=-1.5708 0 3.1416
